# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target MCU-LINK (6160000::V6.16::ARMCLANG)
  device: LPC55S69JBD64:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.1.0
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x20040000,0x4000) IROM(0x00000000,0x098000) XRAM(0x04000000,0x8000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: CMSIS_DAP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;.\board;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x4000000 size 0x8000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x4000
  scatter file: .\RTE\Device\LPC55S69JBD64_cm33_core0\LPC55S69_cm33_core0_flash.scf
  link misc: --diag_suppress=L6314
  group Source
    ./: main.c ser_num.c USBD_User_CustomClass_0.c USBD_User_CDC_ACM_UART_0.c USBD1_LPC55xxx.c fsl_usart.c
  group Documentation
    ./: Abstract.txt
  group Board
    ./board/: clock_config.c peripherals.c pin_mux.c
  group CMSIS DAP
    ./: DAP_config.h
    ../../Source/: DAP.c JTAG_DP.c SW_DP.c SWO.c UART.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:CDC 6.15.0, USB:Device:Custom Class 6.15.0, CMSIS Driver:USART:flexcomm_usart_cmsis 2.2.0, Device:CMSIS:LPC55S69_system 1.0.0, Device:SDK Drivers:clock 2.3.3, Device:SDK Drivers:common 2.3.0, Device:SDK Drivers:dma 2.4.2, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.7, Device:SDK Drivers:iap1 2.1.3, Device:SDK Drivers:iocon 2.2.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:usart 2.6.0, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:usart_dma 2.6.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
