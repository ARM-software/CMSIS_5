# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target XMC4200 (5060020::V5.06 (build 20)::ARMCC)
  device: XMC4200-Q48x256 Infineon
  pack: Infineon.XMC4000_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IROM2(0x0C000000,0x40000) IRAM(0x20000000,0x5FC0) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DAP
  c flags: Optim=1 wLevel=2
  c include: .;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5fc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group Source
    ./: main.c USBD_User_HID_0.c
  group Documentation
    ./: Abstract.txt
  group CMSIS DAP
    ../../Source/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group CMSIS Driver Workaround
    ./: UART.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, CMSIS Driver:USB Device:USB 2.03, Device:RTE_Device 1.0.1, Device:Startup 1.0.0, Device:XMClib:GPIO 2.0.0, Device:XMClib:SCU 2.0.0, Device:XMClib:UART 2.0.0, USB:CORE 6.5.0, USB:Device 6.5.0, USB:Device:HID 6.5.0
