# Keil uVision project Template.uvproj, settings and files
target Simulator (ARM-GNU)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Template
  group Startup
    ./: startup_ARMCM0.s
    ../: system_ARMCM0.c
  group RTX Configuration
    ../../: RTX_Conf_CM.c
  group RTX Library
    ../../../LIB/GCC/: libRTX_CM0.a
  group Source Files
    ../../: main.c
