# IAR project RTX_Lib_CM.ewp, settings and files
configuration CM0_LE (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __CORTEX_M0; __CMSIS_RTOS
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\INC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __CMSIS_RTOS
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM0.a"
  ILINK.IlinkOutputFile: RTX_Lib_CM.out
configuration CM0_BE (ARM)
  as the first configuration, except:
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM0_B.a"
configuration CM3_LE (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: __CORTEX_M3; __CMSIS_RTOS; DBG_MSG
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM3.a"
configuration CM3_LE_IFX (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: __CORTEX_M3; __CMSIS_RTOS; DBG_MSG; IFX_XMC4XXX=1
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM3_IFX.a"
configuration CM3_BE (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: __CORTEX_M3; __CMSIS_RTOS; DBG_MSG
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM3_B.a"
configuration CM4F_LE (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __CORTEX_M4F; __FPU_PRESENT=1; __CMSIS_RTOS; DBG_MSG
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM4.a"
configuration CM4F_LE_IFX (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __CORTEX_M4F; __FPU_PRESENT=1; __CMSIS_RTOS; DBG_MSG; IFX_XMC4XXX=1
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM4_IFX.a"
configuration CM4F_BE (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __CORTEX_M4F; __FPU_PRESENT=1; __CMSIS_RTOS; DBG_MSG
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM4_B.a"
  group HAL
    ../: HAL_CM.c
    ./: HAL_CM0.s HAL_CM3.s HAL_CM4.s SVC_Table.s
  group Kernel
    ../: rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
