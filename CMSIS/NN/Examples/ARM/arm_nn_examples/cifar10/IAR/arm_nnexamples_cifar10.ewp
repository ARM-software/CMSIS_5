# IAR project arm_nnexamples_cifar10.ewp, settings and files
configuration ARMCM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ../../../../../Include; ../../../../../../Core/Include; ../../../../../../DSP/Include; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: arm_nnexamples_cifar10.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: ARMCM0\ARMCM0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ARMCM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: ARM_MATH_CM3; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkIcfFile: ARMCM3\ARMCM3.icf
configuration ARMCM4_FP (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; __FPU_PRESENT=1U; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkIcfFile: ARMCM4_FP\ARMCM4_FP.icf
  ILINK.IlinkAdditionalLibs: C:\Users\thomasto\Projects\CMSIS_5\CMSIS\DSP\Projects\IAR\ReleaseM4LE_FPU\Exe\iar_cortexM4lf_math.a
configuration ARMCM7_SP (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM7; __FPU_PRESENT=1U; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkIcfFile: ARMCM7_SP\ARMCM7_SP.icf
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group Documentation
    ./: readme_iar.txt
  group Source Files
    ../../../../../Source/ConvolutionFunctions/: arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_RGB.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
    ../../../../../Source/FullyConnectedFunctions/: arm_fully_connected_q7.c
    ../: arm_nnexamples_cifar10.cpp
    ../../../../../Source/PoolingFunctions/: arm_pool_q7_HWC.c
    ../../../../../Source/NNSupportFunctions/: arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
    ../../../../../Source/ActivationFunctions/: arm_relu_q7.c
    ../../../../../Source/SoftmaxFunctions/: arm_softmax_q7.c
