# IAR project arm_nnexamples_gru.ewp, settings and files
configuration ARMCM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ../../../../Include; ../../../../../Core/Include; ../../../../../DSP/Include; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkAdditionalLibs: C:\Users\thomasto\Projects\CMSIS_5\CMSIS\DSP\Projects\IAR\ReleaseM0LE\Exe\iar_cortexM0l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ARMCM3 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: ARM_MATH_CM3; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkAdditionalLibs: C:\Users\thomasto\Projects\CMSIS_5\CMSIS\DSP\Projects\IAR\ReleaseM3LE\Exe\iar_cortexM3l_math.a
configuration ARMCM4_FP (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; __FPU_PRESENT=1U; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkAdditionalLibs: C:\Users\thomasto\Projects\CMSIS_5\CMSIS\DSP\Projects\IAR\ReleaseM4LE_FPU\Exe\iar_cortexM4lf_math.a
configuration ARMCM7_SP (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM7; __FPU_PRESENT=1U; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkAdditionalLibs: C:\Users\thomasto\Projects\CMSIS_5\CMSIS\DSP\Projects\IAR\ReleaseM7LE_FPU_SP\Exe\iar_cortexM7ls_math.a
  group Documentation
    ./: readme_iar.txt
  group Source Files
    ../../../../Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15_opt.c
    ../../../../Source/ActivationFunctions/: arm_nn_activations_q15.c
    ./: arm_nnexamples_gru.cpp
    ../../../../Source/NNSupportFunctions/: arm_nntables.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
