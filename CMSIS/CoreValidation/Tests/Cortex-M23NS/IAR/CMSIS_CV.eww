<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Bootloader\Bootloader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CMSIS_CV.ewp</path>
    </project>
    <batchBuild />
</workspace>
