# IAR project debug.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 57
  General.FPU2: 0
  ICCARM.CCDefines: ARMCM23_TZ; _RTE_
  ICCARM.CCIncludePath2: C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Tests\Cortex-M23NS\IAR; C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Tests\Cortex-M23NS\IAR\build\FVP; C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Include; C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Tests\Cortex-M23NS\IAR\RTE\Device\ARMCM23_TZ; C:\tools\Keil_v5\ARM\PACK\ARM\CMSIS\5.1.2-dev3\CMSIS\Include; C:\tools\Keil_v5\ARM\PACK\ARM\CMSIS\5.1.2-dev3\Device\ARM\ARMCM23\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ARMCM23_TZ; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: debug.srec
  ILINK.IlinkOutputFile: debug.out
  ILINK.IlinkIcfFile: C:/Users/jonant01/git/CMSIS_5/CMSIS/CoreValidation/Tests/Cortex-M23NS/IAR/v2m-mps2_ns.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../Source/: cmsis_cv.c CV_CoreFunc.c CV_CoreInstr.c CV_Framework.c CV_MPU_ARMv8.c CV_Report.c
    ../../: main.c
    RTE/Device/ARMCM23_TZ/: startup_ARMCM23.s system_ARMCM23.c
