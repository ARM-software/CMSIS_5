# Keil uVision project debug.uvprojx, settings and files
target armcm23 (ARM-GNU)
  device: ARMCM23 ARM
  pack: ARM.CMSIS.5.5.0-dev2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: armcm23.elf
target armcm33 (ARM-GNU)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.5.0-dev2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") CLOCK(12000000) ESEL ELITTLE
  output: armcm33.elf
target armcm33ns (ARM-GNU)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.5.0-dev2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: armcm33ns.elf
