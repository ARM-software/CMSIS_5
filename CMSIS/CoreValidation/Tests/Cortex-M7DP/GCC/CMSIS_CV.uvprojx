# Keil uVision project CMSIS_CV.uvprojx, settings and files
target FVP (6070000::V6.7::.\ARMCLANG)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.1.2-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  group Test
    ../../../Source/: cmsis_cv.c CV_CoreFunc.c CV_CoreInstr.c CV_Framework.c CV_MPU_ARMv7.c CV_Report.c
    ../../: main.c
    ./: CV_Config.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
