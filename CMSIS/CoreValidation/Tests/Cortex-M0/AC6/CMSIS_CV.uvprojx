# Keil uVision project CMSIS_CV.uvprojx, settings and files
target FVP (6090000::V6.9::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  c include: .\,..\..\..\Include
  asm include: .\,..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
  group Test
    ../../../Source/: cmsis_cv.c CV_CoreFunc.c CV_CoreInstr.c CV_Framework.c CV_Report.c
    ../../: main.c
    ./: CV_Config.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
