# Keil uVision project CMSIS_CV.uvprojx, settings and files
target FVP (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.1.2-dev3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  c include: .\,..\..\..\Include
  asm include: .\,..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
  group Test
    ../../../Source/: cmsis_cv.c CV_CoreFunc.c CV_CoreInstr.c CV_Framework.c CV_MPU_ARMv7.c CV_Report.c
    ../../: main.c
    ./: CV_Config.h
target STM32L053 (6070000::V6.7::.\ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.7.0-dev0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  c include: .\,..\..\..\Include
  asm include: .\,..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1, Device:Startup 1.6.0
