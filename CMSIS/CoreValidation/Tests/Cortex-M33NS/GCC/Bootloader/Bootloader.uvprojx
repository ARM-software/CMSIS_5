# Keil uVision project Bootloader.uvprojx, settings and files
target FVP (6070000::V6.7::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.1.2-dev1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Bootloader
  group Secure Code
    ./: main_s.c tz_context.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.1.0
