# IAR project CMSIS_CV.ewp, settings and files
configuration FVP (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; $PROJ_DIR$; ..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CMSIS_CV.srec
  ILINK.IlinkOutputFile: CMSIS_CV.out
  ILINK.IlinkIcfFile: v2m-mps2_ns.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt
    ../../../Source/: cmsis_cv.c CV_CoreFunc.c CV_CoreInstr.c CV_Framework.c CV_MPU_ARMv8.c CV_Report.c
    ../../: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Documentation/Core/html/: index.html
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Include/: tz_context.h
  group CMSIS-Pack/Device Startup
    RTE/CMSIS/ARM/: partition_ARMCM33.h startup_ARMCM33.s system_ARMCM33.c
