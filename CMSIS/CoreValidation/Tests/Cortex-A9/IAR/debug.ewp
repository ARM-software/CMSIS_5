# IAR project debug.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CortexA9VEFVP Cortex-A9 VE FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 3
  ICCARM.CCDefines: _RTE_; ARMCA9
  ICCARM.CCIncludePath2: C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Tests\Cortex-A9\IAR\build\FVP; C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Tests\Cortex-A9\IAR; C:\tools\PACK\ARM\CMSIS\5.2.1-dev1\Device\ARM\ARMCA9\Include; C:\tools\PACK\ARM\CMSIS\5.2.1-dev1\CMSIS\Core_A\Include; C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Include; C:\Users\jonant01\git\CMSIS_5\CMSIS\CoreValidation\Tests\Cortex-A9\IAR\RTE\Device\ARMCA9
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RTE_; ARMCA9
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: debug.srec
  ILINK.IlinkOutputFile: FVP.elf
  ILINK.IlinkIcfFile: C:/Users/jonant01/git/CMSIS_5/CMSIS/CoreValidation/Tests/Cortex-A9/IAR/RTE/Device/ARMCA9/ARMCA9.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../Source/: cmsis_cv.c CV_CoreAFunc.c CV_CoreInstr.c CV_Framework.c CV_L1Cache.c CV_Report.c
    ../../../../../../../../../tools/PACK/ARM/CMSIS/5.2.1-dev1/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../: main.c
    RTE/Device/ARMCA9/: mmu_ARMCA9.c startup_ARMCA9.s system_ARMCA9.c
