# IAR project CMSIS_CV.ewp, settings and files
configuration FVP (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 51
  General.FPU2: 5
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; $PROJ_DIR$; ..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CMSIS_CV.srec
  ILINK.IlinkOutputFile: CMSIS_CV.out
  ILINK.IlinkIcfFile: RTE\Device\ARMCA7\ARMCA7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Test
    ../../../Source/: cmsis_cv.c CV_CoreAFunc.c CV_CoreInstr.c CV_Framework.c CV_Report.c
    ../../: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Documentation/Core_A/html/: index.html
  group CMSIS-Pack/Device IRQ Controller
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Core_A/Include/: irq_ctrl.h
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.2-dev2}$/CMSIS/Core_A/Source/: irq_ctrl_gic.c
  group CMSIS-Pack/Device Startup
    RTE/CMSIS/ARM/: mem_ARMCA9.h mmu_ARMCA9.c system_ARMCA9.c system_ARMCA9.h
