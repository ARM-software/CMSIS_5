# IAR project CMSIS_CV.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 53
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CMSIS_CV.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/CMSIS/Documentation/Core_A/html/: index.html
  group CMSIS-Pack/CMSIS CORE Validation CoreFunc
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: CV_CoreAFunc.c
  group CMSIS-Pack/CMSIS CORE Validation CoreInstr
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: CV_CoreInstr.c
  group CMSIS-Pack/CMSIS CORE Validation Framework
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: cmsis_cv.c CV_Framework.c CV_Report.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Include/: cmsis_cv.h
    RTE/CMSIS-CORE_Validation/ARM/: CV_Config.h
  group CMSIS-Pack/Device IRQ Controller
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/CMSIS/Core_A/Include/: irq_ctrl.h
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/CMSIS/Core_A/Source/: irq_ctrl_gic.c
  group CMSIS-Pack/Device Startup
    RTE/CMSIS/ARM/: mem_ARMCA9.h mmu_ARMCA9.c system_ARMCA9.c system_ARMCA9.h
