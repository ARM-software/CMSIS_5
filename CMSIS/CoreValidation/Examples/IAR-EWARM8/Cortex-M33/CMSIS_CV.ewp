# IAR project CMSIS_CV.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CMSIS_CV.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/CMSIS/Documentation/Core/html/: index.html
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.1.1-dev1}$/CMSIS/Include/: tz_context.h
  group CMSIS-Pack/CMSIS CORE Validation CoreFunc
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: CV_CoreFunc.c
  group CMSIS-Pack/CMSIS CORE Validation CoreInstr
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: CV_CoreInstr.c
  group CMSIS-Pack/CMSIS CORE Validation Framework
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: cmsis_cv.c CV_Framework.c CV_Report.c
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Include/: cmsis_cv.h
    RTE/CMSIS-CORE_Validation/ARM/: CV_Config.h
  group CMSIS-Pack/CMSIS CORE Validation MPUFunc
    ${CMSIS_PACK_PATH_ARM#CMSIS-CORE_Validation#1.0.0-dev1}$/Source/: CV_MPU_ARMv8.c
  group CMSIS-Pack/Device Startup
    RTE/CMSIS/ARM/: partition_ARMCM33.h startup_ARMCM33.s system_ARMCM33.c
