# Keil uVision project CMSIS_CV.uvprojx, settings and files
target Cortex-M0 (AC6, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
  group main
    ./: main.c
target Cortex-M3 (AC6, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M4f (AC6, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M7 (AC6, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M23 (AC6, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM23_TZ ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M33 (AC6, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-covered-switch-default
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M0 (AC5, FVP) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M3 (AC5, FVP) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M4f (AC5, FVP) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M7 (AC5, FVP) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler
target Cortex-M0 (GCC, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
target Cortex-M3 (GCC, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
target Cortex-M4f (GCC, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
target Cortex-M7 (GCC, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
target Cortex-M23 (GCC, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM23_TZ ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
target Cortex-M33 (GCC, FVP) (6070000::V6.7::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.1.1-dev1
  cpu: as above
  output: CMSIS_CV
software components: CMSIS-Core Validation:CoreFunc 1.0.0, CMSIS-Core Validation:CoreInstr 1.0.0, CMSIS-Core Validation:Framework 1.0.0, CMSIS-Core Validation:MPUFunc 1.0.0, CMSIS:CORE 5.0.2, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.1.0, Device:Startup 1.1.0, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1
