<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RTX_CM.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>RTX_CM</name>
            <member>
                <project>RTX_CM</project>
                <configuration>CM0</configuration>
            </member>
            <member>
                <project>RTX_CM</project>
                <configuration>CM3</configuration>
            </member>
            <member>
                <project>RTX_CM</project>
                <configuration>CM4F</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
