# Keil uVision project RTX_CM.uvprojx, settings and files
target CM0_LE (6050000::V6.5::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy CM0_LE\RTX_CM0.lib ..\.
  c flags: Optim=4 OneElfS=1 v6Lang=3 wLevel=2
  c include: ..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../../../Source/: rtx_kernel.c rtx_thread.c rtx_delay.c rtx_timer.c rtx_evflags.c rtx_mutex.c rtx_semaphore.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_system.c user_svc.c
  group Handlers
    ../../../Source/ARM/: irq_cm0.s irq_cm3.s irq_cm4f.s
target CM3_LE (6050000::V6.5::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy CM3_LE\RTX_CM3.lib ..\.
  c flags: Optim=4 OneElfS=1 v6Lang=3 wLevel=2
  c include: ..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM4F_LE (6050000::V6.5::.\ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM4F (library)
  AfterMake: cmd.exe /C copy CM4F_LE\RTX_CM4F.lib ..\.
  c flags: Optim=4 OneElfS=1 v6Lang=3 wLevel=2
  c include: ..\..\..\Include;..\..\..\..\Include
  asm misc: --no_hide_all
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.0
