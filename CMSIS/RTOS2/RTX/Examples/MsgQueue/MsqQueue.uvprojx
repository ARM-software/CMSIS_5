# Keil uVision project MsqQueue.uvprojx, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.1-dev4
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MsqQueue
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c Abstract.txt
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Device:Startup 1.0.1, Compiler:Event Recorder 1.1.0, Compiler:I/O:STDOUT 1.2.0
