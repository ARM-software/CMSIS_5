# Keil uVision project arm_cortexM_math.uvprojx, settings and files
target cortexM0l (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM0l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM0, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM0
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group BasicMathFunctions
    ../../Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
  group FastMathFunctions
    ../../Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group ComplexMathFunctions
    ../../Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group FilteringFunctions
    ../../Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_partial_f32.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_q7.c arm_conv_q15.c arm_conv_q31.c arm_correlate_f32.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q7.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q7.c arm_fir_q15.c arm_fir_q31.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q7.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c arm_correlate_opt_q15.c arm_conv_opt_q7.c arm_conv_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_opt_q15.c arm_correlate_opt_q7.c arm_correlate_fast_opt_q15.c arm_conv_fast_opt_q15.c arm_conv_partial_fast_opt_q15.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c
  group MatrixFunctions
    ../../Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_inverse_f64.c
  group NNFunctions
    ../../Source/NNFunctions/: arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_depthwise_separable_conv_HWC_q7.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_pool_q7_HWC.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_relu_q7.c arm_relu_q15.c arm_nn_activations_q7.c arm_nn_activations_q15.c arm_softmax_q7.c arm_softmax_q15.c
  group TransformFunctions
    ../../Source/TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c arm_bitreversal.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_f32.c arm_cfft_radix8_f32.c arm_bitreversal2.S arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_cfft_q31.c arm_cfft_q15.c
  group ControllerFunctions
    ../../Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group StatisticsFunctions
    ../../Source/StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group SupportFunctions
    ../../Source/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
  group CommonTables
    ../../Source/CommonTables/: arm_common_tables.c arm_const_structs.c
target cortexM0b (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM0b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM0, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM0
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM3l (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM3l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM3, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM3
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM3b (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM3b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM3, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM3
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4l (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4b (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM4b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4lf (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4lf_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT=1U
  c misc: --fpmode=ieee_full
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4bf (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM4bf_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT=1U, ARM_MATH_BIG_ENDIAN
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7l (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7l_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7b (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM7b_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_BIG_ENDIAN
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7lfsp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfsp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT=1U
  c misc: --fpmode=ieee_full
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7bfsp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM7bfsp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: ARM_MATH_CM7, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT=1U, ARM_MATH_BIG_ENDIAN
  c misc: --fpmode=ieee_full
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7lfdp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfdp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: as above
  c misc: --fpmode=ieee_full
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7bfdp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: arm_cortexM7bfdp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1 wLevel=2
  c define: as above
  c misc: --fpmode=ieee_full
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_CM7
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM7
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBLl (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MBLl_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: ARM_MATH_ARMV8MBL, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, UNALIGNED_SUPPORT_DISABLE
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MBL __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLl (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLl_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: ARM_MATH_ARMV8MML, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, UNALIGNED_SUPPORT_DISABLE
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MMLlfsp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLlfsp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: ARM_MATH_ARMV8MML, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, UNALIGNED_SUPPORT_DISABLE, __FPU_PRESENT=1U
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MMLlfdp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") FPU3(DFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLlfdp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: as above
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MMLld (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLld_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: ARM_MATH_ARMV8MML, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, UNALIGNED_SUPPORT_DISABLE, __DSP_PRESENT=1U
  c misc: -Wno-gnu-statement-expression -Xclang -target-feature -Xclang +t2xtpk
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLldfsp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLldfsp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: ARM_MATH_ARMV8MML, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, UNALIGNED_SUPPORT_DISABLE, __DSP_PRESENT=1U, __FPU_PRESENT=1U
  c misc: as above
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLldfdp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP_DP ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLldfdp_math (library)
  AfterMake: cmd.exe /C copy "!L" "..\..\..\Lib\ARM\"
  c flags: Optim=4 oTime=1
  c define: as above
  c misc: as above
  c include: ..\..\Include;..\..\..\Core\Include;..\..\..\Include
  asm define: ARM_MATH_ARMV8MML __CC_ARM
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
