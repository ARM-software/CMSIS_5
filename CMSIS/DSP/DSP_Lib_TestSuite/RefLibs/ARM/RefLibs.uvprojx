# Keil uVision project RefLibs.uvprojx, settings and files
target cortexM0l (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM0l_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM0
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group BasicMathFunctions
    ../src/BasicMathFunctions/: abs.c add.c dot_prod.c mult.c negate.c offset.c scale.c shift.c sub.c
  group ComplexMathFunctions
    ../src/ComplexMathFunctions/: cmplx_conj.c cmplx_dot_prod.c cmplx_mag.c cmplx_mag_squared.c cmplx_mult_cmplx.c cmplx_mult_real.c
  group ControllerFunctions
    ../src/ControllerFunctions/: sin_cos.c pid.c
  group FastMathFunctions
    ../src/FastMathFunctions/: cos.c sin.c sqrt.c
  group FilteringFunctions
    ../src/FilteringFunctions/: biquad.c conv.c correlate.c fir.c fir_decimate.c fir_lattice.c fir_sparse.c iir_lattice.c lms.c fir_interpolate.c
  group MatrixFunctions
    ../src/MatrixFunctions/: mat_cmplx_mult.c mat_inverse.c mat_mult.c mat_scale.c mat_sub.c mat_trans.c mat_add.c
  group StatisticsFunctions
    ../src/StatisticsFunctions/: max.c mean.c min.c power.c rms.c std.c var.c
  group SupportFunctions
    ../src/SupportFunctions/: copy.c fill.c fixed_to_fixed.c fixed_to_float.c float_to_fixed.c
  group TransformFunctions
    ../src/TransformFunctions/: cfft.c rfft.c dct4.c
  group Intrinsics
    ../src/Intrinsics/: intrinsics.c
  group HelperFunctions
    ../src/HelperFunctions/: ref_helper.c mat_helper.c
target cortexM0b (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM0b_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM0, ARM_MATH_BIG_ENDIAN
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM3l (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM3l_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM3
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM3b (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM3b_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM3, ARM_MATH_BIG_ENDIAN
  c include: ..\inc;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4l (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4l_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM4
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4b (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM4b_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM4, ARM_MATH_BIG_ENDIAN
  c include: ..\inc;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4lf (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM4lf_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM4,__FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM4bf (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM4bf_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM4,ARM_MATH_BIG_ENDIAN,__FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7l (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7l_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM7
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7lfsp (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfsp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM7,__FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7lfdp (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_cortexM7lfdp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM7,__FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7b (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM7b_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM7, ARM_MATH_BIG_ENDIAN
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7bfsp (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM7bfsp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM7,ARM_MATH_BIG_ENDIAN,__FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cortexM7bfdp (5060417::V5.06 update 4 (build 417)::ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: arm_cortexM7bfdp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_CM7,ARM_MATH_BIG_ENDIAN,__FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBLl (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MBLl_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MBL
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MMLl (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLl_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLlfsp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLlfsp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML, __FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLlfdp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLlfdp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML, __FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLld (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLld_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML, __DSP_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLldfsp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLldfsp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML, __DSP_PRESENT=1U, __FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
target ARMv8MMLldfdp (6060000::V6.6::.\ARMCLANG)
  device: ARMv8MML_DSP_DP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(DFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: arm_ARMv8MMLldfdp_ref (library)
  AfterMake: cmd.exe /C copy "!L" ".\Lib\"
  c flags: Optim=1
  c define: ARM_MATH_ARMV8MML, __DSP_PRESENT=1U, __FPU_PRESENT=1U
  c include: ..\inc;..\..\..\Include;..\..\..\..\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
